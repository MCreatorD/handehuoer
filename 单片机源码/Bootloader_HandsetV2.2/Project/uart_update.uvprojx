# Keil uVision project uart_update.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F429VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_update
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER
  c include: ..\User_Code\User;..\User_Code\Bsp_Drive;..\User_Code\Download;..\User_Code\IAP;..\User_Code\Flash_Download;..\ST_Lib\CMSIS\Device\ST\STM32F4xx\Include;..\ST_Lib\CMSIS\Include;..\ST_Lib\STM32F4xx_StdPeriph_Driver\inc;..\User_Code\FPGA_Download
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../ST_Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../ST_Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../ST_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Bsp_Drive
    ../User_Code/Bsp_Drive/: bsp_uart_update.c common.c BspTime.c sys.c delay.c stmflash.c printf_usart.c
  group Download
    ../User_Code/Download/: download.c ymodem.c
  group IAP
    ../User_Code/IAP/: iap.c
  group User
    ../User_Code/User/: main.c stm32f4xx_it.c
  group Flash_Download
    ../User_Code/Flash_Download/: EN25Q256.c spi.c flash_download.c
  group SerialDownloadUpdateFontLib
    ../User_Code/Flash_Download/: flash_updateFont.c
  group FPGA_Download
    ../User_Code/FPGA_Download/: fpga_download.c fpga_epcs.c sim_spi1.c fpga_pwr_en.c
