# Keil uVision project UHF_HB_ISSUSER.uvprojx, settings and files
target stm32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Handhour0614hb_r
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,Wang_5_10
  c include: ..\Src\lib\STM32F4xx_StdPeriph_Driver\inc;..\Src\lib\CMSIS\Device\ST\STM32F4xx\Include;..\Src\lib\CMSIS\Include;..\Src\_Common;..\Src\usr;..\Src\lib\libltkcpp;..\Src\usr\comm_model;..\Src\usr\general_model;..\Src\usr\operation_model;..\Src\usr\hw_model;..\Src\usr\main_model;..\Src\lib\libsm2;..\Src\usr\certification_model;..\Src\usr\extendllrp;..\Src\usr\vm_model;..\Src\usr\rf_model;..\Src\usr\hw_model;..\Src\usr\FPGA_Download;..\Src\usr\DataScope;..\Src\usr\log_model
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main_Model
    ../Src/usr/main_model/: GetDeviceCapabilities.cpp GetDeviceCapabilities.h main_application.h main_application.cpp model_base.h model_base.cpp param_manager.cpp param_manager.h
  group CMSIS
    ../Src/lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Startup
    ../Src/lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group Common
    ../Src/_Common/: usart.c systick.c
  group StdPeriph_Driver
    ../Src/lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Libltkcpp
    ../Src/lib/libltkcpp/: ltkcpp_array.cpp ltkcpp_element.cpp LLRP_Capabilities.cpp LLRP_General.cpp LLRP_NET.cpp LLRP_Operation.cpp ltkcpp_encdec.cpp ltkcpp_error.cpp ltkcpp_framedecode.cpp ltkcpp_frameencode.cpp ltkcpp_frameextract.cpp ltkcpp_genout.cpp ltkcpp_hdrfd.cpp ltkcpp_typeregistry.cpp ltkcpp_xmltextencode.cpp
  group General_Model
    ../Src/usr/general_model/: HbFrame_Operation.cpp HEXConvert.cpp general.h class_retain.cpp general_functions.cpp ManufacturerFrame.cpp ManufacturerFrame.h
  group Comm_Model
    ../Src/usr/comm_model/: base_comm.cpp serial_comm.cpp uart_bsp_comm.c
  group log_model
    ../Src/usr/log_model/: log_process.cpp mod_logSysInfo.c
  group Operation_Model
    ../Src/usr/operation_model/: operationspec_execute_base.h operationreport_manager.cpp operationreport_manager.h operationspec_manager.cpp operationspec_manager.h tag_accessspec.cpp tag_accessspec.h tag_selectspec.cpp tag_selectspec.h tag_selectaccessresult.cpp tag_selectaccessresult.h OpspecResult.cpp OpspecResult.h tag_spec.cpp tag_spec.h operationspec_execute_base.cpp operation_process.cpp operation_process.h rf_oper_base.cpp Rf_Oper_gb.cpp Rf_Oper_gb.h operationspec_execute_gb.cpp operationspec_execute_gb.h cancellation.c cancellation.h operationspec_execute_hb.cpp operationspec_execute_hb.h Rf_Oper_hb.cpp Rf_Oper_hb.h
  group HW_Model
    ../Src/usr/hw_model/: IOCtrl.cpp MCUToSecureComm.cpp MCUToSecureComm.h SPI_Communication.cpp rtc.c spi.c i2c.c sim_spi.c gpio.c AD5602.c board.c sim_spi1.c mcu_led.c cpu_5v_en.c buzzer_led.c fpga.c fpga_pwr_en.c sm.c EN25Q256.c ad_bat.c sec_3v3_en.c rf_5V5_en.c Bsp_init.c readtag_key.cpp
    ../Src/usr/operation_model/: rf_oper_base.h
    ../Src/usr/: lowpower.c
  group Start_Model
    ../Src/usr/: main.c stm32f4xx_it.c
    ../Src/lib/CMSIS/: Retarget.c
  group LibSm2
    ../Src/lib/libsm2/: mraes.c mralloc.c mrarth0.c mrarth1.c mrarth2.c mrarth3.c mrbits.c mrbrick.c mrcore.c mrcrt.c mrcurve.c mrebrick.c mrec2m.c mrecn2.c mrfast.c mrgcd.c mrgcm.c mrgf2m.c mrio1.c mrio2.c mrjack.c mrlucas.c mrmonty.c mrpower.c mrprime.c mrrand.c mrscrt.c mrshs.c mrshs256.c mrshs512.c mrsmall.c mrsroot.c mrstrong.c mrxgcd.c mrzzn2.c mrzzn2b.c mrzzn3.c sm2.c sm3.c
  group Certification_Model
    ../Src/usr/certification_model/: Sm2Certification.cpp Sm2Certification.h miracl.h mirdef.h sm2.h sm3.h types.h
  group ExtendLLRP
    ../Src/usr/extendllrp/: ExtendHbFrame_Operation.cpp ExtendHbFrame_Operation.h ExtendLLRP.cpp ExtendLLRP.h ExtendLLRP_Message_ID.h
  group Vm_Model
    ../Src/usr/vm_model/: VersionManager.cpp VersionManager.h Update_SM_Firmware.cpp Update_SM_Firmware.h Update_Mcu_Firmware.cpp
  group Rf_Model
    ../Src/usr/rf_model/: rf_manager.cpp rf_manager.h
  group FPGA_Download
    ../Src/usr/FPGA_Download/: fpga_download.c fpga_epcs.c
  group DataScope
    ../Src/usr/DataScope/: DataScope_DP.C
